# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=550,1
  c include: .\Start;.\Library;.\User;.\System;.\App;.\Middlewares\FreeRTOS;.\Middlewares\FreeRTOS\include;.\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c
  group Library
    ./Start/: system_stm32f10x.h
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Board_Config.h M3PWM.c M3PWM.h Motor_ctr.c Motor_ctr.h ABEncoder.c ABEncoder.h ADC_get.c ADC_get.h Uart_Config.c Uart_Config.h RGB_Led.c RGB_Led.h Led_Status.c Led_Status.h LSM6DSR_Config.c LSM6DSR_Config.h pose.c pose.h Key_Scan.c Key_Scan.h BlackPoint_Finder.c BlackPoint_Finder.h Act.c Act.h PID_Controller.c PID_Controller.h Car_Control.c Car_Control.h
  group App
    ./App/: app_main.c app_ctrl.c app_keys.c app_serial.c app_state.c app_config.h app_state.h
  group FreeRTOS
    ./Middlewares/FreeRTOS/: FreeRTOSConfig.h tasks.c queue.c list.c timers.c event_groups.c
    ./Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ./Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
